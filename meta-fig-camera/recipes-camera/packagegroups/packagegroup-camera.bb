# meta-fig-camera/recipes-camera/packagegroups/packagegroup-camera.bb

SUMMARY = "Camera Services"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = ""