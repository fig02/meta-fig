require u-boot-common.inc
require u-boot.inc

PV = "2024.04"
SRCREV = "refs/tags/v2024.04"
DEPENDS += "bc-native dtc-native gnutls-native python3-pyelftools-native"
